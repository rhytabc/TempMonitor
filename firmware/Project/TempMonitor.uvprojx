# Keil uVision project TempMonitor.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TempMonitor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Users;D:\Keil5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include;D:\Keil5\ARM\PACK\Keil\STM32F1xx_DFP\2.2.0\Device\Includ;D:\Keil5\ARM\PACK\Keil\STM32F1xx_DFP\2.2.0\Device\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    D:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/2.2.0/Device/Source/ARM/: startup_stm32f10x_md.s
    ../User/: delay.c ds18b20.c main.c onewire.c usart.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c system_stm32f10x.c nrf24l01.c spi.c stm32f10x_spi.c
